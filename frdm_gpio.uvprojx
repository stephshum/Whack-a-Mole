# Keil uVision project frdm_gpio.uvprojx, settings and files
target frdm_gpio (ARM-ADS)
  device: MK64FN1M0xxx12 NXP
  pack: NXP.MK64F12_DFP.10.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: frdm_gpio
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DTARGET_KSDK2_MCUS -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_KPSDK_CODE --split_sections -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_RELEASE -DTARGET_MCU_K64F --no_rtti -DARM_MATH_CM4 -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_FLASH=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_MBED -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DTARGET_FRDM -DFEATURE_STORAGE=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DTARGET_CORTEX_M -DDEVICE_SERIAL=1 -DTARGET_KPSDK_MCUS -DTARGET_Freescale -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTARGET_CORTEX -DDEVICE_LOWPOWERTIMER=1 -DTARGET_MCUXpresso_MCUS -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DDEVICE_ANALOGIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -D__CMSIS_RTOS --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DDEVICE_TRNG=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_K64F -DCPU_MK64FN1M0VMD12 -DDEVICE_STORAGE=1 -DDEVICE_PORTIN=1 -DTARGET_M4 -DMBED_BUILD_TIMESTAMP=1526588614.89 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -DFSL_RTOS_MBED -DDEVICE_SPI_ASYNCH=1 -D__MBED_CMSIS_RTOS_CM
  c include: .;RGB_matrix_Panel;RGB_matrix_Panel/Adafruit-GFX;SNESController;mbed/.;mbed/TARGET_K64F;mbed/TARGET_K64F/TARGET_Freescale;mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS;mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F;mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/TARGET_FRDM;mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device;mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/drivers;mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/api;mbed/TARGET_K64F/TOOLCHAIN_ARM_STD;mbed/drivers;mbed/hal;mbed/platform;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DCPU_MK64FN1M0VMD12,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DFSL_RTOS_MBED
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/MK64FN1M0xxx12.sct
  link misc: --show_full_path
  group frdm_gpio
    ./: controller_test.cpp game.cpp game.h gamestate_test.cpp led_test.cpp oldgame.cpp utils.h
    /tmp/tmpFv89vt/: mbed_config.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h TableCRC.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h critical_section_api.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o crc.o dma_api.o flash_api.o fsl_adc16.o fsl_clock.o fsl_clock_config.o fsl_cmp.o fsl_cmt.o fsl_common.o fsl_crc.o fsl_dac.o fsl_dmamux.o fsl_dspi.o fsl_dspi_edma.o fsl_edma.o fsl_enet.o fsl_ewm.o fsl_flash.o fsl_flexbus.o fsl_flexcan.o fsl_ftm.o fsl_gpio.o fsl_i2c.o fsl_i2c_edma.o fsl_llwu.o fsl_lptmr.o fsl_mpu.o fsl_pdb.o fsl_phy.o fsl_pit.o fsl_pmc.o fsl_rcm.o fsl_rnga.o fsl_rtc.o fsl_sai.o fsl_sai_edma.o fsl_sdhc.o fsl_sim.o fsl_smc.o fsl_uart.o fsl_uart_edma.o fsl_vref.o fsl_wdog.o gpio_api.o gpio_irq_api.o i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o mbed_retarget.o mbed_sdk_boot.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o rtc_api.o serial_api.o sleep.o spi_api.o startup_MK64F12.o storage_driver.o system_MK64F12.o trng_api.o us_ticker.o
    mbed/TARGET_K64F/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h semihost_api.h SingletonPtr.h sleep.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device/: cmsis.h cmsis_nvic.h fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/TARGET_FRDM/: crc.h device.h fsl_clock_config.h fsl_phy.h PeripheralNames.h PinNames.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/api/: dma_api_hal.h gpio_object.h objects.h PeripheralPins.h PortNames.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/: dma_reqs.h peripheral_clock_defines.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/drivers/: fsl_adc16.h fsl_clock.h fsl_cmp.h fsl_cmt.h fsl_common.h fsl_crc.h fsl_dac.h fsl_dmamux.h fsl_dspi.h fsl_dspi_edma.h fsl_edma.h fsl_enet.h fsl_ewm.h fsl_flash.h fsl_flexbus.h fsl_flexcan.h fsl_ftm.h fsl_gpio.h fsl_i2c.h fsl_i2c_edma.h fsl_llwu.h fsl_lptmr.h fsl_mpu.h fsl_pdb.h fsl_pit.h fsl_pmc.h fsl_port.h fsl_rcm.h fsl_rnga.h fsl_rtc.h fsl_sai.h fsl_sai_edma.h fsl_sdhc.h fsl_sim.h fsl_smc.h fsl_uart.h fsl_uart_edma.h fsl_vref.h fsl_wdog.h
    mbed/: mbed.h
    mbed/TARGET_K64F/TARGET_Freescale/: mbed_rtx.h
  group RGB_matrix_Panel
    RGB_matrix_Panel/Adafruit-GFX/: Adafruit_GFX.cpp Adafruit_GFX.h glcdfont.h
    RGB_matrix_Panel/: gamma.h RGBmatrixPanel.cpp RGBmatrixPanel.h
  group SNESController
    SNESController/: SNESController.h
